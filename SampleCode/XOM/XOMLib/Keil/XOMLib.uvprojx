# Keil uVision project XOMLib.uvprojx, settings and files
target XOMLib (6230000::V6.23::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: ..\..\lib\xomlib (library)
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\;..\..\..\..\Library\Device\Nuvoton\m3331\Config;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Src
    ../: xomlib.c
