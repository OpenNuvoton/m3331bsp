# Keil uVision project Template.uvprojx, settings and files
target Template (6230000::V6.23::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M33") FPU2
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c startup_m3331.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
  group User
    ../: main.c
