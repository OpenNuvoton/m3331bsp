# IAR project HSOTG_Dual_Role_UMAS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\m3331\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FatFs\source; ..\..\..\..\Library\UsbHostLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSOTG_Dual_Role_UMAS.bin
  ILINK.IlinkOutputFile: HSOTG_Dual_Role_UMAS.out
  ILINK.IlinkIcfFile: HSOTG_Dual_Role_UMAS.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c hsusbd.c retarget.c sys.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group User
    ../: descriptors.c diskio.c main.c massstorage.c
