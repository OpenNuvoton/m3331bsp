# Keil uVision project ISP_DFU_20.uvprojx, settings and files
target ISP_DFU_20 (6230000::V6.23::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.1
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M33") FPU2 IROM(0x00000000,0x80000) IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000)
  output: ISP_DFU_20
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-pragma-pack -mno-unaligned-access -Wconditional-uninitialized
  c include: ..\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\m3331\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\m3331\Config\m3331_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c
  group User
    ../: descriptors.c main.c fmc_user.c dfu_transfer.c startup_m3331_user.S hsusbd_user.c targetdev.c isp_user.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c
